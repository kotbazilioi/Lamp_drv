# IAR project lwip_udpecho_freertos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 NXP MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; CPU_MKV58F1M0VLQ24; USE_RTOS=1; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; TWR_KV58F220M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../../../rtos/freertos_8.2.3/Source/include; ; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKV58F24/drivers; ..; ../../../../../../../devices/MKV58F24/utilities; ../../../../../../../middleware/lwip_2.0.0; ../../../../../../../middleware/lwip_2.0.0/port; ../../../../../../../middleware/lwip_2.0.0/port/arch; ../../../../../../../middleware/lwip_2.0.0/src; ../../../../../../../middleware/lwip_2.0.0/src/include; ../../../../../../../middleware/lwip_2.0.0/src/include/lwip; ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv; ../../../../../../../middleware/lwip_2.0.0/src/include/netif; ../../../../../../../middleware/lwip_2.0.0/src/include/posix; ../../../../../../../middleware/lwip_2.0.0/src/include; ../../../../../../../middleware/lwip_2.0.0/contrib/apps; ../../../../../../../rtos/freertos_8.2.3/Source; ../../../../..; ../../../../../../../devices/MKV58F24; ..\..\..\..\..\..\..\middleware\dma_manager_2.0.0; ..; ..\..\..\..\..\..\..\rtos\freertos_8.2.3\Source\portable\MemMang; ..\..\..\..\..\..\..\middleware\lwip_2.0.0\contrib\apps\httpserver; ..\ssd1306; ..\..\..\..\..\..\..\middleware\lwip_2.0.0\src\include\lwip\apps; ..\..\..\..\..\..\..\middleware\lwip_2.0.0\src\apps\httpd
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: lwip_udpecho_freertos.bin
  ILINK.IlinkOutputFile: lwip_udpecho_freertos.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_app_remap_to_0x10040000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F; ../../../../../../../rtos/freertos_8.2.3/Source/include; ; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../devices/MKV58F24/drivers; ..; ../../../../../../../devices/MKV58F24/utilities; ../../../../../../../middleware/lwip_2.0.0/port; ../../../../../../../middleware/lwip_2.0.0/port/arch; ../../../../../../../middleware/lwip_2.0.0/src; ../../../../../../../middleware/lwip_2.0.0/src/include; ../../../../../../../middleware/lwip_2.0.0/src/include/lwip; ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv; ../../../../../../../middleware/lwip_2.0.0/src/include/netif; ../../../../../../../middleware/lwip_2.0.0/src/include/posix; ../../../../../../../middleware/lwip_2.0.0/src/include; ../../../../../../../middleware/lwip_2.0.0/contrib/apps; ../../../../../../../rtos/freertos_8.2.3/Source; ../../../../..; ../../../../../../../devices/MKV58F24; ..\..\..\..\..\..\..\middleware\lwip_2.0.0; ..\..\..\..\..\..\..\middleware\lwip_2.0.0\contrib\apps\httpserver; ..\..\..\..\..\..\..\rtos\freertos_8.2.3\Source\portable\MemMang; ..\..\..\..\..\..\..\..\..\oled\iarduino_OLED-1.1.0\src; ..\..\..\..\..\..\..\..\..\oled\ssd1306; ..\ssd1306; ..\..\..\..\..\..\..\..\..\..\lamp_app\SDK_2.0_TWR-KV58F220M2\middleware\lwip_2.0.0\src\apps\httpd; ..\..\..\..\..\..\..\middleware\lwip_2.0.0\port; ..\..\..\..\..\..\..\middleware\lwip_2.0.0\src\include\lwip\apps; ..\..\..\..\..\..\..\middleware\lwip_2.0.0\src\apps\httpd; D:\Projects\MainLDrv20\lamp_app\SDK_2.0_TWR-KV58F220M2\middleware\lwip_2.0.0\src\include\lwip; ..\html
  ICCARM.CCOptStrategy: 1
  group board
    ./: base64.c
    ../: board.c board.h clock_config.c clock_config.h fsl_phy.c fsl_phy.h hard_init.c hard_init.h html_page.c pflash.c pin_mux.c pin_mux.h
    ../ssd1306/: fonts.c fonts.h ssd1306.c ssd1306.h ssd1306_i2c.c ssd1306_i2c.h
  group drivers
    ../../../../../../../devices/MKV58F24/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_flash.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_ftm.c fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_xbara.c fsl_xbarb.c
    ../../../../../../../middleware/dma_manager_2.0.0/: fsl_dma_manager.c fsl_dma_manager.h
  group freertos
    ../../../../../../../rtos/freertos_8.2.3/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../rtos/freertos_8.2.3/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/MemMang/: heap_5.c
  group freertos/portable
    ../../../../../../../rtos/freertos_8.2.3/Source/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group lwip/port
    ../../../../../../../middleware/lwip_2.0.0/port/arch/: cc.h perf.h sys_arch.h
    ../../../../../../../middleware/lwip_2.0.0/port/: ethernetif.c ethernetif.h lwipopts.h sys_arch.c
  group lwip/src/api
    ../../../../../../../middleware/lwip_2.0.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../../middleware/lwip_2.0.0/src/apps/httpd/: httpd.c
    ../../../../../../../middleware/lwip_2.0.0/contrib/apps/httpserver/: httpserver-netconn.c
  group lwip/src/core
    ../../../../../../../middleware/lwip_2.0.0/src/core/: def.c dns.c inet_chksum.c init.c ip.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../../../../../../middleware/lwip_2.0.0/src/apps/httpd/: fs.c
  group lwip/src/core/ipv4
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
  group lwip/src/core/ipv6
    ../../../../../../../middleware/lwip_2.0.0/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/ipv4
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group lwip/src/include/lwip
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/: api.h arch.h debug.h def.h dhcp.h dhcp6.h dns.h err.h ethip6.h icmp6.h init.h ip4.h ip4_addr.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timers.h udp.h
  group lwip/src/include/lwip/priv
    ../../../../../../../middleware/lwip_2.0.0/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/netif
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/: etharp.h slipif.h
  group lwip/src/include/netif/ppp
    ../../../../../../../middleware/lwip_2.0.0/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/posix
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/: netdb.h
    ../../../../../../../middleware/lwip_2.0.0/src/include/posix/sys/: socket.h
  group lwip/src/netif
    ../../../../../../../middleware/lwip_2.0.0/src/netif/: etharp.c ethernet.c lowpan6.c slipif.c
  group lwip/src/netif/ppp
    ../../../../../../../middleware/lwip_2.0.0/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip_udpecho
    ../../../../../../../middleware/lwip_2.0.0/contrib/apps/tcpecho/: tcpecho.c tcpecho.h
    ../../../../../../../middleware/lwip_2.0.0/contrib/apps/udpecho/: udpecho.c udpecho.h
  group source
    ../: app.c frame_decod.c frame_decod.h FreeRTOSConfig.h lwip_udpecho_freertos.c
  group startup
    ../../../../../../../devices/MKV58F24/iar/: startup_MKV58F24.s
    ../../../../../../../devices/MKV58F24/: system_MKV58F24.c system_MKV58F24.h
  group utilities
    ../../../../../../../devices/MKV58F24/utilities/: fsl_debug_console.c fsl_debug_console.h
